# Keil uVision project srobot.uvprojx, settings and files
target qitas (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: srobot +hex
  AfterMake: fromelf.exe --bin -o./srobot.bin ./obj/srobot.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STLib;..\STLib\inc;..\USER;..\USER\FLASH;..\USER\MAKER;..\USER\MOTOR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../USER/: main.c usart.c sys.c spi.c iic.c delay.c adc.c watchdog.c beep.c
  group flash
    ../USER/FLASH/: flash.c 24cxx.c
  group motor
    ../USER/MOTOR/: stepper.c
  group maker
    ../USER/MAKER/: maker.c planner.c temperature.c motion_control.c ConfigurationStore.c
  group STlibs
    ../STLib/src/: misc.c stm32f10x_it.c stm32f10x_spi.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_wwdg.c system_stm32f10x.c stm32f10x_dbgmcu.c
    ../STLib/: core_cm3.c startup_stm32f10x_hd.s
software components: CMSIS:CORE 4.3.0
